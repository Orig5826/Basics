# Keil uVision project stm32f103c8t6.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c8t6
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Library;..\Library\CoreSupport;..\Library\DeviceSupport\STM32F10x;..\Library\Drivers\inc;..\Library\Register\inc;.\Source;..\Example;..\Demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../Library/CoreSupport/: core_cm3.c
  group Devices
    ../Library/DeviceSupport/STM32F10x/: system_stm32f10x.c
    ../Library/DeviceSupport/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Drivers
    ../Library/Drivers/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group Register
    ../Library/Register/src/: reg_gpio.c reg_uart.c reg_tim.c reg_flash.c
  group Source
    ./Source/: main.c
  group Example
    ../Example/: uart.c led.c stm32f10x_it.c timer.c i2c.c
  group Demo
    ../Demo/: gpio_demo.c uart_demo.c tim_demo.c flash_demo.c
  group doc
    ./: Notes.md
