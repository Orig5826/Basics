# Keil uVision project stm32f103c8t6.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c8t6
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;..\Library\inc;..\Library\device;..\Demo
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../Library/device/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group library
    ../Library/src/: reg_flash.c reg_gpio.c reg_tim.c reg_uart.c
  group source
    ./Source/: main.c
  group demo
    ../Demo/: flash_demo.c gpio_demo.c tim_demo.c uart_demo.c
