# Keil uVision project Custom_CCID.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c8t6
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\..\Library;..\..\Library\CoreSupport;..\..\Library\DeviceSupport\STM32F10x;..\..\Library\Drivers\inc;..\..\Library\USB-FS-Device_Driver\inc;.\inc;.\app
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../../Library/CoreSupport/: core_cm3.c
  group Devices
    ../../Library/DeviceSupport/STM32F10x/: system_stm32f10x.c
    ../../Library/DeviceSupport/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Drivers
    ../../Library/Drivers/src/: misc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_i2c.c
  group usb_driver
    ../../Library/USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Source
    ./src/: hw_config.c main.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group app
    ./app/: i2c_hard.c usb_ccid_i2c_demo.c
  group doc
    ../: Notes.md
